COMPATIBLE_MACHINE_vkrzv2l = "vkrzv2l"

PLATFORM_FLAVOR_vkrzv2l = "g2l_smarc_2"

